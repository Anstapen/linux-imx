## drivers/ast_custom/Kconfig
```kconfig
config AUDIO_AST_DRIVER
	tristate "Custom AST audio driver"
	help
	  Enables the custom audio driver by AST
```
